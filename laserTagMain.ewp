# IAR project laserTagMain.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K6 STM8L151K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCDefines: STM8L15X_MD; USE_FULL_ASSERT
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: laserTagMain.hex
  ILINK.IlinkOutputFile: laserTagMain.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; USE_FULL_ASSERT
  group (top)
    ./: main.c
  group Include
    Include/: Accelerometer.h AT24C04.h delay.h key.h led.h mainStr.h MRF24J40.h MyI2C.h myiic.h systemTick.h time.h usart.h
  group Source
    Source/: Accelerometer.c AT24C04.c delay.c key.c led.c mainStr.c MRF24J40.c MyI2C.c myiic.c systemTick.c time.c usart.c
  group STM8L Library/Include
    STM8L Library/Include/: stm8l15x.h stm8l15x_clk.h stm8l15x_conf.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_it.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim4.h stm8l15x_usart.h
  group STM8L Library/Source
    STM8L Library/Source/: stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_it.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim4.c stm8l15x_usart.c
